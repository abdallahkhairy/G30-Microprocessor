# Keil uVision project Lab4.uvproj, settings and files
target Project1 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: IO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c startup.s tm4c123gh6pm.h
    ../Project1/: APP.h CounterTO999.c Delay.c Delay.h DIO.c DIO.h DIO_Reg.h LCD.c LCD.h LCD_Config.h SevSegments.c SevSegments.h SevSegments_Config.h STD_TYPES.h TExaS.h
